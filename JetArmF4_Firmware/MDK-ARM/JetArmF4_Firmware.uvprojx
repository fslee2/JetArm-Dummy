# Keil uVision project JetArmF4_Firmware.uvprojx, settings and files
target JetArmF4_Firmware (6190000::V6.19::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: JetArmF4_Firmware +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Hiwonder/Misc;../Hiwonder/Peripherals;../Hiwonder/Portings;../Hiwonder/System;../Third_Party/Lw;../Third_Party/RTT;../Hiwonder
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group ThirdParty
    ../Third_Party/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../Third_Party/Lw/: lwmem.c lwmem_sys_cmsis_os.c lwpkt.c lwrb.c lwshell.c
  group Hiwonder/Peripherals
    ../Hiwonder/Peripherals/: button.c led.c buzzer.c pwm_servo.c serial_servo.c
  group Hiwonder/Misc
    ../Hiwonder/Misc/: log.c checksum.c packet.c
  group Hiwonder/Portting
    ../Hiwonder/Portings/: led_porting.c button_porting.c buzzer_porting.c lwmem_porting.c pwm_servo_porting.c serial_servo_porting.c packet_porting.c lwmem_porting.h motor_porting.c
  group Hiwonder/System
    ../Hiwonder/System/: app.c packet_handle.c packet_handle.h
    ../Hiwonder/: global_conf.h global_include.h
software components: CMSIS:CORE 5.6.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0
